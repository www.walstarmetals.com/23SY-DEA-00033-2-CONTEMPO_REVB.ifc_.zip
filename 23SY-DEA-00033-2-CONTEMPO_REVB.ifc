Properties of the parts of a building model (IFC2X3)

# File
Description: Unknown
File name: 23SY-DEA-00033-2-CONTEMPO_REVB
Time: 2023-08-25T11:47:04-05:00
Author: Unknown
Organization: Unknown
Written by: ST-DEVELOPER v18.102
Made in: Unknown
Authorization: OpenTools
Comment: Generated by software containing ST-Developer * from STEP Tools, Inc. (www.steptools.com)
Comment: OPTION: strings as raw bytes, not using required /X/ escapes
Comment: description
Comment: implementation_level
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorisation

# IfcBuilding, Default Building
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm
